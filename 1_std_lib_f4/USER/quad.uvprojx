# Keil uVision project quad.uvprojx, settings and files
target quad (5060960::V5.06 update 7 (build 960)::.\ARMv5)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: quad +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, HSE_VALUE=8000000
  c include: ..\CORE;..\USER;..\LIB\Stm32_Lib\inc;..\LIB\FreeRTOS_Lib;..\LIB\FreeRTOS_Lib\include;..\LIB\FreeRTOS_Lib\portable\Keil\MDK-ARM;..\LIB\PS2_Lib;..\LIB\IMU_Lib\DMP;..\LIB\IMU_Lib\I2C
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s
  group LIB
    ../LIB/Stm32_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS_LIB
    ../LIB/FreeRTOS_Lib/: croutine.c list.c queue.c tasks.c timers.c
    ../LIB/FreeRTOS_Lib/portable/Keil/MDK-ARM/: port.c
    ../LIB/FreeRTOS_Lib/portable/MemMang/: heap_2.c
  group PS2_LIB
    ../LIB/PS2_Lib/: PS2_ctrl.c
  group IMU_LIB
    ../LIB/IMU_Lib/I2C/: I2Cdev.c
    ../LIB/IMU_Lib/DMP/: MPU6050.c MPU6050_6Axis_MotionApps20.c
software components: CMSIS:CORE 6.0.0
